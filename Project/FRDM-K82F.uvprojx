# Keil uVision project FRDM-K82F.uvprojx, settings and files
target FRDM-K82F (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK82FN256xxx15 NXP
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FRDM-K82F
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK82FN256VDC15, FRDM_K82F, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=66,1296,186
  c include: ..\User;..\Board;..\MK82F25615;..\CMSIS\Include;..\MK82F25615\drivers;..\MK82F25615\utilities
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\MK82F25615\arm\MK82FN256xxx15_flash.scf
  link misc: --remove
  group User
    ../User/: main.c
  group Startup
    ../MK82F25615/: system_MK82F25615.c
    ../MK82F25615/arm/: startup_MK82F25615.s
  group Drivers
    ../MK82F25615/drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lptmr.c fsl_lpuart.c fsl_smc.c
  group Board
    ../Board/: board.c clock_config.c pin_mux.c delay.c
  group Utilities
    ../MK82F25615/utilities/: fsl_debug_console.c
